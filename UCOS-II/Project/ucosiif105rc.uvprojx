# Keil uVision project ucosiif105rc.uvprojx, settings and files
target ucosii-f105rc (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucosii-f105 +hex
  c flags: Optim=1 uC99=1
  c include: ..\Libraries;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Startup;..\User;..\usosii\Ports;..\usosii\Source;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Libraries
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/: STM32F10xR.LIB
  group Startup
    ../Startup/: startup_stm32f10x_cl.s
  group UCOSII_Source
    ../usosii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_Ports
    ../usosii/Ports/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group User
    ../User/: main.c stm32f10x_it.c includes.h LED.c
    ../usosii/Source/: os_cfg.h
    ../Libraries/src/: stm32f10x_flash.c
  group BSP
    ../BSP/: BSP.c BSP.h timer3.c
  group STDLIB
    ../Libraries/src/: stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_iwdg.c
